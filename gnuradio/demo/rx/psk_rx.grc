options:
  parameters:
    author: david
    generate_options: qt_gui
    id: psk_rx
    output_language: python
    title: PSK Receiver
  states: {}

blocks:
- name: downsampling
  id: variable
  parameters:
    value: '2'
  states: {}
- name: frac_resampling
  id: variable
  parameters:
    value: '5'
  states: {}
- name: frame_size
  id: variable
  parameters:
    value: len(preamble_and_padding) + payload_size
  states: {}
- name: frame_size_bits
  id: variable
  parameters:
    value: frame_size * 8
  states: {}
- name: frame_size_samples_after_downsampling
  id: variable
  parameters:
    value: frame_size_samples_before_downsampling // downsampling
  states: {}
- name: frame_size_samples_before_downsampling
  id: variable
  parameters:
    value: frame_size_symbols * upsampling
  states: {}
- name: frame_size_symbols
  id: variable
  parameters:
    value: frame_size_bits // modulation.bits_per_symbol
  states: {}
- name: freq
  id: variable
  parameters:
    value: 220e6
  states: {}
- name: freq_correction
  id: variable
  parameters:
    value: '40'
  states: {}
- name: mod_amplitude
  id: variable
  parameters:
    value: '1'
  states: {}
- name: mod_labels
  id: variable
  parameters:
    value: '[0, 1, 3, 2]'
  states: {}
- name: mod_phase_offset
  id: variable
  parameters:
    value: np.pi / 4
  states: {}
- name: mod_preamble
  id: variable
  parameters:
    value: np.array([-0.7071067811865477-0.7071067811865475j, -0.7071067811865477-0.7071067811865475j, -0.7071067811865477-0.7071067811865475j, -0.7071067811865477-0.7071067811865475j, -0.7071067811865477-0.7071067811865475j, 0.7071067811865476+0.7071067811865475j, 0.7071067811865476+0.7071067811865475j, -0.7071067811865477-0.7071067811865475j, -0.7071067811865477-0.7071067811865475j, 0.7071067811865476+0.7071067811865475j, -0.7071067811865477-0.7071067811865475j, 0.7071067811865476+0.7071067811865475j, -0.7071067811865477-0.7071067811865475j, 0.7071067811865476+0.7071067811865475j, 0.7071067811865476+0.7071067811865475j, 0.7071067811865476+0.7071067811865475j])
  states: {}
- name: modulation
  id: variable
  parameters:
    value: sksdr.QPSK
  states: {}
- name: msg_size
  id: variable
  parameters:
    value: 11 + 4
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '28'
  states: {}
- name: preamble_and_padding
  id: variable
  parameters:
    value: np.array([255, 195, 204, 192], dtype=np.uint8)
  states: {}
- name: rrc_coeffs
  id: variable
  parameters:
    value: sksdr.rrc(upsampling, 0.5, 10)
  states: {}
- name: rx_filter_sps
  id: variable
  parameters:
    value: int(upsampling / downsampling)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.024e6
  states: {}
- name: upsampling
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: test.iq
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: test.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: test_before_upsampling.iq
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: modulation.bits_per_symbol
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import logging

      import numpy as np
      import sksdr
      from gnuradio import gr

      _log = logging.getLogger(__name__)
      #_log.setLevel(logging.DEBUG)


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, message_size=1, payload_size=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              self.message_size = message_size
              self.payload_size = payload_size
              gr.sync_block.__init__(
                  self,
                  name='decode_frame',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.set_output_multiple(self.payload_size)

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              print(len(in0))
              for i in range(0, len(in0), self.payload_size):
                  print("".join(map(chr, in0[i : i + self.message_size])))
              return len(in0)
    message_size: msg_size
    payload_size: payload_size
  states: {}
- name: grsksdr_agc_1
  id: grsksdr_agc
  parameters:
    avg_len: frame_size_samples_before_downsampling
    det_gain: '0.01'
    max_gain: '60'
    ref_power: '0.25'
  states: {}
- name: grsksdr_coarse_freq_comp_0
  id: grsksdr_coarse_freq_comp
  parameters:
    frame_size: frame_size_samples_after_downsampling
    freq_res: '1'
    mod_order: modulation.order
    sample_rate: samp_rate/2
  states: {}
- name: grsksdr_descrambler_0
  id: grsksdr_descrambler
  parameters:
    init_state: '[0, 3, 2, 2, 5, 1, 7]'
    poly: '[1, 0, 1, 1, 0, 1, 0 ,1]'
  states: {}
- name: grsksdr_fir_decimator_0
  id: grsksdr_fir_decimator
  parameters:
    coeffs: rrc_coeffs
    downsampling: downsampling
  states: {}
- name: grsksdr_frame_sync_0
  id: grsksdr_frame_sync
  parameters:
    frame_size: frame_size_symbols
    preamble: mod_preamble
    threshold: '8.0'
  states: {}
- name: grsksdr_freq_sync_0
  id: grsksdr_freq_sync
  parameters:
    damp_factor: '1'
    modulation: '''sksdr.QPSK'''
    norm_loop_bw: '0.01'
    sps: rx_filter_sps
  states: {}
- name: grsksdr_phase_offset_est_0
  id: grsksdr_phase_offset_est
  parameters:
    frame_size: frame_size_symbols
    preamble: mod_preamble
  states: {}
- name: grsksdr_psk_demod_0
  id: grsksdr_psk_demod
  parameters:
    amplitude: mod_amplitude
    labels: mod_labels
    modulation: '''sksdr.QPSK'''
    phase_offset: mod_phase_offset
  states: {}
- name: grsksdr_symbol_sync_0
  id: grsksdr_symbol_sync
  parameters:
    A: 1/np.sqrt(2)
    K: '1'
    damp_factor: '1'
    modulation: '''sksdr.QPSK'''
    norm_loop_bw: '0.01'
    sps: rx_filter_sps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import sksdr
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: frac_resampling
    type: complex
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import logging
      logging.getLogger('grsksdr.frame_sync').setLevel(logging.DEBUG-1)
      logging.getLogger('grsksdr.phase_offset_est').setLevel(logging.DEBUG)
      logging.getLogger('grsksdr.descramber').setLevel(logging.DEBUG)
      logging.getLogger('grsksdr.hamming_decoder').setLevel(logging.DEBUG)

      #self.psk = sksdr.PSKModulator.from_modulation(self.modulation, self.mod_labels, self.mod_amplitude, self.mod_phase_offset)
      #self.psk.modulate(self.preamble_and_padding, self.mod_preamble)
      #print(self.mod_preamble)
    priority: ''
    section: main_after_init
  states: {}
- name: soapy_source_1
  id: soapy_source
  parameters:
    balance0: '0'
    center_freq0: freq
    correction0: freq_correction
    dc_offset0: '0'
    dc_removal0: 'False'
    devname: rtlsdr
    overall_gain0: '0'
    samp_rate: samp_rate
    tuner_gain0: '20'
    type: fc32
  states: {state: disabled}
- name: stream_demux_stream_demux_0
  id: stream_demux_stream_demux
  parameters:
    lengths: '[len(preamble_and_padding), payload_size]'
    num_outputs: '2'
    type: byte
    vlen: '1'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_1, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_1_0, '0']
- [blocks_throttle_1, '0', grsksdr_agc_1, '0']
- [blocks_throttle_1, '0', mmse_resampler_xx_0, '0']
- [blocks_throttle_1_0, '0', grsksdr_frame_sync_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', stream_demux_stream_demux_0, '0']
- [epy_block_0, '0', blocks_null_sink_0_0, '0']
- [grsksdr_agc_1, '0', grsksdr_fir_decimator_0, '0']
- [grsksdr_coarse_freq_comp_0, '0', grsksdr_freq_sync_0, '0']
- [grsksdr_descrambler_0, '0', epy_block_0, '0']
- [grsksdr_fir_decimator_0, '0', grsksdr_coarse_freq_comp_0, '0']
- [grsksdr_frame_sync_0, '0', blocks_null_sink_0_0_0, '0']
- [grsksdr_frame_sync_0, '0', grsksdr_phase_offset_est_0, '0']
- [grsksdr_freq_sync_0, '0', grsksdr_symbol_sync_0, '0']
- [grsksdr_phase_offset_est_0, '0', grsksdr_psk_demod_0, '0']
- [grsksdr_psk_demod_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [grsksdr_symbol_sync_0, '0', blocks_null_sink_0_0_1, '0']
- [grsksdr_symbol_sync_0, '0', grsksdr_frame_sync_0, '0']
- [mmse_resampler_xx_0, '0', grsksdr_agc_1, '0']
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [rtlsdr_source_0, '0', mmse_resampler_xx_0, '0']
- [soapy_source_1, '0', blocks_file_sink_0, '0']
- [soapy_source_1, '0', mmse_resampler_xx_0, '0']
- [stream_demux_stream_demux_0, '0', blocks_null_sink_0, '0']
- [stream_demux_stream_demux_0, '1', grsksdr_descrambler_0, '0']

metadata:
  file_format: 1
