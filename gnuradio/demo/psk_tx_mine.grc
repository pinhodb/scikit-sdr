options:
  parameters:
    generate_options: qt_gui
    id: psk_tx_mine
    output_language: python
    title: PSK Transmitter
  states: {}

blocks:
- name: fec_ndata
  id: variable
  parameters:
    value: '4'
  states: {}
- name: fec_ntotal
  id: variable
  parameters:
    value: '4'
  states: {}
- name: fec_rate
  id: variable
  parameters:
    value: fec_ntotal / fec_ndata
  states: {}
- name: fill_size_bits
  id: variable
  parameters:
    value: payload_size_bits - msg_size_bits
  states: {}
- name: frac_resampling
  id: variable
  parameters:
    value: 1/5
  states: {}
- name: frame_size_bits
  id: variable
  parameters:
    value: '250'
  states: {}
- name: frame_size_samples
  id: variable
  parameters:
    value: frame_size_symbols * upsampling
  states: {}
- name: frame_size_symbols
  id: variable
  parameters:
    value: int(frame_size_bits / modulation.bits_per_symbol)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 220e6
  states: {}
- name: freq_correction
  id: variable
  parameters:
    value: '0'
  states: {}
- name: mod_amplitude
  id: variable
  parameters:
    value: '1'
  states: {}
- name: mod_labels
  id: variable
  parameters:
    value: '[0, 1, 3, 2]'
  states: {}
- name: mod_phase_offset
  id: variable
  parameters:
    value: np.pi / 4
  states: {}
- name: modulation
  id: variable
  parameters:
    value: sksdr.QPSK
  states: {}
- name: msg_size
  id: variable
  parameters:
    value: txt_size + 4
  states: {}
- name: msg_size_bits
  id: variable
  parameters:
    value: msg_size * 8
  states: {}
- name: payload_fec_size_bits
  id: variable
  parameters:
    value: int(payload_size_bits * fec_rate)
  states: {}
- name: payload_size_bits
  id: variable
  parameters:
    value: '224'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: np.repeat(sksdr.UNIPOLAR_BARKER_SEQ[13], 2)
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: rrc_coeffs
  id: variable
  parameters:
    value: sksdr.rrc(upsampling, 0.5, 10)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.024e6
  states: {}
- name: txt_size
  id: variable
  parameters:
    value: '11'
  states: {}
- name: upsampling
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: test.dat
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: msg.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: '[len(preamble), payload_fec_size_bits]'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: preamble
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport logging\nfrom logging import DEBUG\n\nimport numpy as np\n\nimport sksdr\nfrom gnuradio import gr\n\n_log = logging.getLogger(__name__)\n#_log.setLevel(logging.DEBUG)\n\nclass blk(gr.basic_block):\n    \"\"\"\n    \"\"\"\n    def __init__(self, txt_size=11, payload_size=224):\n        self.payload_size = payload_size\n        self.txt_size = txt_size\n        self.counter = 0\n        gr.basic_block.__init__(self,\n                               name='build_frame',\n                               in_sig=[(np.uint8)],\n                               out_sig=[(np.uint8)])\n        self.set_output_multiple(self.payload_size)\n\n    def forecast(self, noutput_items, ninput_items_required):\n        # setup size of input_items[i] for work call\n        for i in range(len(ninput_items_required)):\n            ninput_items_required[i] = noutput_items\n\n    def general_work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n        # print('len(in0), len(out): {}, {}'.format(len(in0), len(out)))\n        for xstart, ystart in zip(range(0, len(in0), self.txt_size), range(0, len(out), self.payload_size)):\n            xend = xstart + self.txt_size\n            bin_txt = sksdr.x2binlist(in0[xstart:xend], 8)\n            yend = ystart + len(bin_txt)\n            out[ystart:yend] = bin_txt\n            bin_counter = sksdr.x2binlist(' {:03d}'.format(self.counter % 100), 8)\n            y = yend\n            yend = y + len(bin_counter)\n            out[y:yend] = bin_counter\n            fill = np.random.randint(0, 1, self.payload_size - (yend - ystart))\n            y = yend\n            yend = y + len(fill)\n            out[y:yend] = fill\n            # print('ystart, yend: {}, {}'.format(ystart, yend))\n            # print('out[ystart:yend]: {}'.format(out[ystart:yend]))\n            self.counter += 1\n        # print('xend, yend: {}, {}'.format(xend, yend))\n        self.consume(0, xend)\n        return yend\n\n"
    payload_size: payload_size_bits
    txt_size: txt_size
  states: {}
- name: grsksdr_fir_interpolator_0
  id: grsksdr_fir_interpolator
  parameters:
    coeffs: rrc_coeffs
    upsampling: upsampling
  states: {}
- name: grsksdr_hamming_encoder_0
  id: grsksdr_hamming_encoder
  parameters:
    ndata: fec_ndata
    ntotal: fec_ntotal
  states: {state: disabled}
- name: grsksdr_psk_mod_0
  id: grsksdr_psk_mod
  parameters:
    amplitude: mod_amplitude
    labels: mod_labels
    modulation: '''sksdr.QPSK'''
    phase_offset: mod_phase_offset
  states: {}
- name: grsksdr_scrambler_0
  id: grsksdr_scrambler
  parameters:
    init_state: '[0, 1, 1, 0]'
    poly: '[1, 1, 1,  0, 1]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import sksdr
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: frac_resampling
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"driver=rtlsdr"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    marker2: '0'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_1_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import logging
      logging.getLogger('grsksdr.hamming_encoder').setLevel(logging.DEBUG)
    priority: ''
    section: main_after_init
  states: {}
- name: soapy_sink_0
  id: soapy_sink
  parameters:
    amp_gain0: '0'
    center_freq0: freq
    devname: hackrf
    gain_auto_mode0: 'True'
    overall_gain0: rf_gain
    samp_rate: samp_rate
    type: fc32
    vga_gain0: rf_gain
  states: {state: disabled}
- name: stream_demux_stream_demux_0
  id: stream_demux_stream_demux
  parameters:
    lengths: 1, 1
    num_outputs: '2'
    type: complex
    vlen: '1'
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_1_1, '0']
- [blocks_char_to_float_1_0, '0', qtgui_time_sink_x_1_1_0, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_file_source_0_0, '0', epy_block_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_stream_mux_0, '0', grsksdr_psk_mod_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '0']
- [epy_block_0, '0', blocks_char_to_float_1_0, '0']
- [epy_block_0, '0', grsksdr_scrambler_0, '0']
- [grsksdr_fir_interpolator_0, '0', mmse_resampler_xx_0, '0']
- [grsksdr_fir_interpolator_0, '0', qtgui_freq_sink_x_0, '0']
- [grsksdr_fir_interpolator_0, '0', qtgui_time_sink_x_1, '0']
- [grsksdr_psk_mod_0, '0', grsksdr_fir_interpolator_0, '0']
- [grsksdr_scrambler_0, '0', blocks_stream_mux_0, '1']
- [mmse_resampler_xx_0, '0', osmosdr_sink_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_const_sink_x_0, '0']
- [mmse_resampler_xx_0, '0', soapy_sink_0, '0']

metadata:
  file_format: 1
