options:
  parameters:
    generate_options: qt_gui
    id: psk_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 220e6
  states: {}
- name: freq_correction
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: rrc_coeffs
  id: variable
  parameters:
    value: sksdr.rrc(upsampling, 0.5, 10)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.024e6
  states: {}
- name: upsampling
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: test.dat
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[1+1j, -1+1j, 1-1j, -1-1j]/np.sqrt(2)'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import sksdr
  states: {}
- name: interp_fir_filter_xxx_1
  id: interp_fir_filter_xxx
  parameters:
    interp: upsampling
    taps: rrc_coeffs
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    marker2: '0'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: soapy_sink_0
  id: soapy_sink
  parameters:
    amp_gain0: '0'
    center_freq0: freq
    devname: hackrf
    gain_auto_mode0: 'True'
    overall_gain0: rf_gain
    samp_rate: samp_rate
    type: fc32
    vga_gain0: rf_gain
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_1, '0']
- [interp_fir_filter_xxx_1, '0', qtgui_const_sink_x_0, '0']
- [interp_fir_filter_xxx_1, '0', qtgui_time_sink_x_1, '0']
- [interp_fir_filter_xxx_1, '0', soapy_sink_0, '0']

metadata:
  file_format: 1
